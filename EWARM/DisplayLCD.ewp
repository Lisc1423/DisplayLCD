# IAR project DisplayLCD.ewp, settings and files
configuration DisplayLCD (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../GUI_FUNC; ../GUI/Lib; ../GUI/inc; ../GUI/Config; ..\simplelib; ..\simplelib\can; ..\simplelib\cmd; ..\simplelib\core; ..\simplelib\flash; ..\simplelib\nrf; ..\simplelib\utils; ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DisplayLCD.hex
  ILINK.IlinkOutputFile: DisplayLCD.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: ILI93xx.c ledpwm.c
  group Application/User/GUI_Func
    ../GUI_FUNC/: GUI_Frame.c map.c robocon_image.c
  group Application/User/SimpleLib
    ../simplelib/: simplelib.c simplelib.h simplelib_cfg.h
  group Application/User/SimpleLib/CAN
    ../simplelib/can/: can_func.c can_func.h can_utils.c can_utils.h
  group Application/User/SimpleLib/CMD
    ../simplelib/cmd/: cmd.c cmd.h cmd_func.c cmd_func.h
  group Application/User/SimpleLib/core
    ../simplelib/core/: flags.c flags.h
  group Application/User/SimpleLib/nrf
    ../simplelib/nrf/: nrf24l01.c nrf24l01.h nrf_comm.c nrf_comm.h
  group Application/User/SimpleLib/utils
    ../simplelib/utils/: hash.c hash.h utils.c utils.h
  group Application/User/STemwin/GUI_Config
    ../GUI/Config/: GUIConf.c GUIConf.h GUIDRV_Template.c GUIDRV_Template.h LCDConf_FlexColor_Template.c LCDConf_FlexColor_Template.h
  group Application/User/STemwin/GUI_Inc
    ../GUI/inc/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Generic.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group Application/User/STemwin/GUI_Lib
    ../GUI/Lib/: STemWin522_CM4_IAR.a
  group Application/User/STemwin/Os
    ../GUI/OS/: GUI_X.c
  group Application/User/System
    ../Src/: adc.c can.c crc.c dma.c fsmc.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c sys.c tim.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c
